;
; DA1B.asm
;
; Created: 9/22/2019 8:13:28 PM
; Author : Kyungseo Yun
;
.include <m328pdef.inc>

.EQU STARTADDS = 0X0200

.ORG 0
	CLR R0
	LDI XL, LOW(STARTADDS)
	LDI XH, HIGH(STARTADDS)
	LDI YL, LOW(0X0300)
	LDI YH, HIGH(0X0300)
	LDI ZL, LOW(0X0500)
	LDI ZH, HIGH(0X0500)
	LDI R21, 0X04
	LDI R22, 0X06
	LDI R23, 249
	LDI R17, 0X03
	LDI R19, 0X05
	
LOOP1 :		ST X, R22
			INC XL
			ST Z, R22
			LD R18, Z+
			DEC R21
			INC R22
			DEC R23
			CP R23, R0
			BREQ DONE
			CP R21, R0
			BREQ LOOP2
			JMP LOOP1

LOOP2 :	
			ST X, R22
			INC XL
			ST Y, R22
			LD R16, Y+
			LDI R21, 0X04
			INC R22
			DEC R23
			JMP LOOP1
	

DONE :		RJMP DONE
